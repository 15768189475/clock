# Keil uVision project rtx.uvprojx, settings and files
target rtx (6120000::V6.12::.\ARMCLANG)
  device: APM32F030C8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 3968_rtx
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APM32F030
  c include: ..\apm_lib\apm32f030\inc;..\apm_lib\apm32f030\startup;..\hw_lib\ground;..\hw_lib\middle;..\hw_lib\top;..\hw_lib\main;..\rtx_lib;..\apm_lib\apm32f030\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ../hw_lib/main/: main.c draw.c servo.c main.h
    ../rtx_lib/: cmsis_os.h
  group gound
    ../hw_lib/ground/: g_adc.c g_adc.h g_clock.c g_clock.h g_gpio.c g_gpio.h g_pwm.c g_pwm.h g_timer.c g_timer.h g_uart.c g_uart.h
  group apm32f030
    ../apm_lib/apm32f030/src/: apm32f0xx_adc.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_rcm.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c
  group startup
    ../apm_lib/apm32f030/startup/: startup_apm32f030.s system_apm32f0xx.c
software components: CMSIS:RTOS:Keil RTX 4.81.1
